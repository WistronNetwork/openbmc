EXTRA_OEMESON:append = " -Dsensor-monitor-hard-shutdown-delay=0"
EXTRA_OEMESON:append = " -Dsensor-monitor-soft-shutdown-delay=60000"
