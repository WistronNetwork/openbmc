EXTRA_OEMESON:append = " \
     -Dhttp-body-limit=96 \
     "

EXTRA_OEMESON:remove = " \
     -Dredfish-cpu-log=enabled  \
     "
