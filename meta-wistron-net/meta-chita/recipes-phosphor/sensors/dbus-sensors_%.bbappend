PACKAGECONFIG:chita = "\
    hwmontempsensor \
    fansensor \
    psusensor \
    adcsensor \
    "
