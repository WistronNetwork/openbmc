RDEPENDS:${PN}-system:remove:chita = " \
        bmcweb \
        phosphor-ipmi-kcs \
        phosphor-ipmi-ipmb \
        phosphor-post-code-manager \
        phosphor-host-postd \
        webui-vue \
        "
