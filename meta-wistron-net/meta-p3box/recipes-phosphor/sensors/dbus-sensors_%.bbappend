PACKAGECONFIG = "\
    hwmontempsensor \
    fansensor \
    psusensor \
    adcsensor \
    "
