FILESEXTRAPATHS:prepend:chita := "${THISDIR}/${PN}:"

SRC_URI:append:chita = "file://obmc"
