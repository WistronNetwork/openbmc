PACKAGECONFIG:append = "oem-platform"

SRC_URI = "git://git@github.com/WistronNetwork/wistron-net-ipmi-oem.git;branch=master;protocol=ssh"
