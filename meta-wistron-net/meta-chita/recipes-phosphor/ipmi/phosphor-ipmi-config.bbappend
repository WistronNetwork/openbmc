FILESEXTRAPATHS:prepend:chita := "${THISDIR}/${PN}:"
